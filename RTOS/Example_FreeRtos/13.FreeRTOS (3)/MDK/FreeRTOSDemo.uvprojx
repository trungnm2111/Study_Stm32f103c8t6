# Keil uVision project FreeRTOSDemo.uvprojx, settings and files
target FreeRTOS (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FreeRTOSDemo +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\USER\FreeRTOS\include;..\USER;..\USER\FreeRTOS\portable\RVDS\ARM_CM3;..\USER\N5110;..\USER\SPI
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group OS
    ../USER/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../USER/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../USER/FreeRTOS/portable/MemMang/: heap_1.c
  group Delay
    ../USER/: Delay.c
  group USER
    ../USER/: main.c
  group N5110
    ../USER/SPI/: SPI.c
    ../USER/N5110/: N5110.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0
